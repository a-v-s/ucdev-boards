# Repository a-v-s/ucdev-boards

## KiCad design slimme_meter_pmod/slimme_meter_pmod.kicad_pcb

Parts:
C1, C2: C_Polarized_Small; CP_Radial_D5.0mm_P2.50mm
D1, D2: 1N5819; D_DO-35_SOD27_P10.16mm_Horizontal
J1: RJ12
J2: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal
J3: Conn_02x01; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2: 2N7000; TO-92_Inline
Q3: BS250; TO-92_Inline
R1, R2, R3, R4: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: LP2950-3.3_TO92; TO-92_Inline

Connections:
+3V3: C2.1, J3.1, U1.1 (VO)
+5V: C1.1, D2.1 (K), Q3.3 (S), R2.1, R4.1, U1.3 (VI)
CTS: J2.11, Q1.2 (G), R3.2
GND: C1.2, C2.2, J1.3, J1.6, J2.3, J2.4, Q1.1 (S), Q2.1 (S), R3.1, U1.2 (GND)
MCU_DATA: J2.7, Q2.3 (D), R1.2
unnamed: D1.2 (A), Q3.1 (D)
unnamed: D2.2 (A), J1.1
unnamed: Q1.3 (D), Q3.2 (G), R4.2
RTS: J2.5
SM_DATA_REQUEST: D1.1 (K), J1.2
TXD: J2.9
VCC: J2.1, J2.2, J3.2, R1.1
~SM_DATA: J1.5, Q2.2 (G), R2.2

Board: 2 copper layers, 52.1 x 22.9 mm, 15 parts (0 on the bottom side), 11 nets.

## KiCad design radio/868/RFM9xW_868/RFM9xW_868.kicad_pcb

Board: 2 copper layers, 52.1 x 22.9 mm, 12 parts (6 on the bottom side), 12 nets.

Parts:
AE1: Antenna; Texas_SWRA416_868MHz_915MHz
C1, C2: C_Small; C_0805_2012Metric
J1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal
JP1: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
M1: DNP; R_0805_2012Metric
M2: 1 pF; R_0805_2012Metric
M3: 12 nH; R_0805_2012Metric
R1, R2: R_Small; R_0805_2012Metric
U1: RFM95W-868S2; HOPERF_RFM9XW_SMD
U2: SPI FLASH; SOP-8_3.9x4.9mm_P1.27mm

Connections:
DIO0: J1.12, U1.14 (DIO0)
GND: C1.2, C2.2, J1.3, J1.4, JP1.1 (A), M1.2, M3.2, U1.1 (GND), U1.8 (GND), U1.10 (GND), U2.4 (VSS)
MISO: J1.7, U1.2 (MISO), U2.2 (O1/SO)
MOSI: J1.9, U1.3 (MOSI), U2.5 (SI/IO0)
unnamed: AE1.1 (A), M2.2, M3.1
unnamed: JP1.2 (C), U2.3 (~WP)
unnamed: M1.1, M2.1, U1.9 (ANT)
SCK: J1.5, U1.4 (SCK), U2.6 (SCLK)
VCC: C1.1, C2.1, J1.1, J1.2, JP1.3 (B), R1.1, R2.1, U1.13 (3.3V), U2.8 (VCC)
nCS: J1.11, R2.2, U1.5 (NSS)
nCS2: J1.8, R1.2, U2.1 (~CS)
nRESET: J1.10, U1.6 (RESET)

## KiCad design modem/sim800x_break/sim800x_break.kicad_pcb

Board: 2 copper layers, 51.4 x 94.0 mm, 75 parts (0 on the bottom side), 49 nets.

Parts:
C1, C2, C3, C19, C20, C21: 10 pF; C_0805_2012Metric
C4, C5, C18, C22, C23, C24: 33 pF; C_0805_2012Metric
C6: 100 nF; C_0805_2012Metric
C7: 1 uF; C_0805_2012Metric
C8, C14: 470 uF; CP_Radial_D10.0mm_P5.00mm
C9: 2u2; C_0805_2012Metric
C10: 2n2; C_0805_2012Metric
C11, C13, C25: 1u; C_0805_2012Metric
C12, C16, C17: 10u; C_0805_2012Metric
C26: 100n; C_0805_2012Metric
D1: LED; LED_0805_2012Metric
D2, D3, D12: D_Schottky; D_0805_2012Metric
H1, H2: MountingHole_3.2mm_M3_Pad_Via
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2, J3: AudioJack3; Jack_3.5mm_CUI_SJ1-3535NG_Horizontal
J5: USB_B_Micro; USB_Micro-B_XKB_U254-05XX-4BH806
L1, L2: 6u8; L_Bourns_SRP7028A_7.3x6.6mm
PMOD1, PMOD2, PMOD3: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal
PMOD4, PMOD5, PMOD6: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal
Q1: 2N7002; SOT-23
R1, R2, R3, R4, R5, R10: 1K; R_0805_2012Metric
R6, R7: 5K6; R_0805_2012Metric
R8, R17, R18: 10K; R_0805_2012Metric
R9, R12, R16: 100K; R_0805_2012Metric
R11: 2K2; R_0805_2012Metric
R13: 56K; R_0805_2012Metric
R14: 22K; R_0805_2012Metric
R15: 100R; R_0805_2012Metric
TP1, TP2, TP3, TP4: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: SIM800L_Breakout
U2: LTC4054ES5-4.2; TSOT-23-5
U3: XB330xS; SOT-23-3
U4: LMR62421XMF; SOT-23-5
U5: LP5907MFX-3.3; SOT-23-5
U6, U7, U8, U9: CH213K; SOT-23-3

Connections:
BAT+: D2.2 (A), J1.1, Q1.1 (G), R9.1, R15.1, U2.3 (BAT), U9.3 (A)
BAT-: C26.1, J1.2, R11.2, U3.3 (GND)
DCDC_IN: C11.2, C16.2, L1.1, R12.1, TP2.1, U4.5 (VIN), U6.2 (K), U7.2 (K)
DCDC_OUT: C10.2, C13.2, C17.2, D12.1 (K), R13.1, TP3.1, U8.3 (A)
ENABLE_LDO: D2.1 (K), D3.1 (K), R17.1
GND: C2.1, C3.2, C4.1, C6.2, C7.2, C8.2, C11.1, C12.1, C13.1, C14.2, C16.1, C17.1, C18.2, C19.1, C21.2, C22.1, C24.2, C25.1, J5.5 (GND), J5.6 (Shield), L2.2, PMOD1.3, PMOD1.4, PMOD2.3, PMOD2.4, PMOD3.3, PMOD3.4, PMOD4.3, PMOD4.4, PMOD5.3, PMOD5.4, PMOD6.3, PMOD6.4, Q1.2 (S), R6.1, R7.1, R9.2, R14.2, R16.2, TP1.1, U1.6 (GND), U2.2 (GND), U3.1 (VM), U4.2 (GND), U5.2 (GND), U6.1 (GND), U7.1 (GND), U8.1 (GND), U9.1 (GND)
MCU_DTR: PMOD2.8, R3.2, R7.2
MCU_RING: PMOD2.12, R4.2
MCU_RXD: PMOD2.7, R2.2
MCU_TXD: PMOD2.9, R1.2, R6.2
MCU_nRST: PMOD2.10, R5.2
MIC+: C19.2, C20.1, C22.2, C23.1, J2.R, J2.T, U1.10 (MICP)
MIC-: C20.2, C21.1, C23.2, C24.1, J2.S, U1.9 (MICN)
MOD_DTR: R3.1, U1.11 (DTR)
MOD_RING: R4.1, U1.12 (RING)
MOD_RXD: R1.1, U1.4 (RxD)
MOD_TXD: R2.1, U1.5 (TxD)
MOD_nRST: R5.1, U1.3 (RST)
unnamed: D1.2 (A), R10.2
unnamed: D1.1 (K), U2.1 (~CHRG)
unnamed: C9.2, D12.2 (A), L2.1
unnamed: Q1.3 (D), R18.1
unnamed: R11.1, U2.5 (PROG)
unnamed: C26.2, R15.2, U3.2 (VDD)
unnamed: R8.2, R12.2, R18.2, U4.4 (EN)
unnamed: C10.1, R13.2, R14.1, U4.3 (FB)
unnamed: C9.1, L1.2, U4.1 (SW)
unnamed: R16.1, R17.2, U5.3 (EN)
PMOD_I2C_GPIO1: PMOD1.12, PMOD4.12
PMOD_I2C_GPIO2: PMOD1.10, PMOD4.10
PMOD_I2C_GPIO3: PMOD1.8, PMOD4.8
PMOD_I2C_GPIO4: PMOD1.6, PMOD4.6
PMOD_I2C_INT: PMOD1.11, PMOD4.11
PMOD_I2C_RESET: PMOD1.9, PMOD4.9
PMOD_I2C_SCL: PMOD1.7, PMOD4.7
PMOD_I2C_SDA: PMOD1.5, PMOD4.5
PMOD_SPI_CS: PMOD3.11, PMOD5.11
PMOD_SPI_GPIO1_INT: PMOD3.12, PMOD5.12
PMOD_SPI_GPIO2_RESET: PMOD3.10, PMOD5.10
PMOD_SPI_GPIO3_CS2: PMOD3.8, PMOD5.8
PMOD_SPI_GPIO4_CS3: PMOD3.6, PMOD5.6
PMOD_SPI_MISO: PMOD3.7, PMOD5.7
PMOD_SPI_MOSI: PMOD3.9, PMOD5.9
PMOD_SPI_SCK: PMOD3.5, PMOD5.5
SPK+: C1.1, C2.2, C4.2, C5.1, J3.R, J3.T, U1.8 (SPKP)
SPK-: C1.2, C3.1, C5.2, C18.1, J3.S, U1.7 (SPKN)
VBUS: D3.2 (A), J5.1 (VBUS), R8.1, R10.1, U2.4 (V_{CC}), U7.3 (A)
VCC: C12.2, C25.2, PMOD1.1, PMOD1.2, PMOD2.1, PMOD2.2, PMOD3.1, PMOD3.2, PMOD4.1, PMOD4.2, PMOD5.1, PMOD5.2, PMOD6.1, PMOD6.2, U5.5 (OUT), U6.3 (A)
VMODEM: C6.1, C7.1, C8.1, C14.1, TP4.1, U1.2 (VCC), U5.1 (IN), U8.2 (K), U9.2 (K)

## KiCad design i2c_oled/i2c_display.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
JP1, JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
U1: MOD_OLED_I2C; MOD_OLED_I2C_128x64_1.3

Connections:
GND: JP1.3 (B), JP2.3 (B); also elsewhere on the board
PWR1: JP1.2 (C), U1.1 (PWR)
PWR2: JP2.2 (C), U1.2 (PWR)
SCL: U1.3 (SCL); also elsewhere on the board
SDA: U1.4 (SDA); also elsewhere on the board
VCC: JP1.1 (A), JP2.1 (A); also elsewhere on the board

Parts:
J1, J2, J3: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal
J4, J5, J6: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal

Connections:
GND: J1.3, J1.4, J2.3, J2.4, J3.3, J3.4, J4.3, J4.4, J5.3, J5.4, J6.3, J6.4; also elsewhere on the board
INT: J1.11, J4.11
IO1: J1.12, J4.12
IO2: J1.10, J4.10
IO3: J1.8, J4.8
IO4: J1.6, J4.6
PMOD_SPI_CS: J3.11, J6.11
PMOD_SPI_CS2: J3.8, J6.8
PMOD_SPI_CS3: J3.6, J6.6
PMOD_SPI_INT: J3.12, J6.12
PMOD_SPI_MISO: J3.7, J6.7
PMOD_SPI_MOSI: J3.9, J6.9
PMOD_SPI_RESET: J3.10, J6.10
PMOD_SPI_SCK: J3.5, J6.5
PMOD_UART_CTS: J2.11, J5.11
PMOD_UART_GPIO3: J2.8, J5.8
PMOD_UART_GPIO4: J2.6, J5.6
PMOD_UART_INT: J2.12, J5.12
PMOD_UART_RESET: J2.10, J5.10
PMOD_UART_RTS: J2.5, J5.5
PMOD_UART_RXD: J2.7, J5.7
PMOD_UART_TXD: J2.9, J5.9
RESET: J1.9, J4.9
SCL: J1.7, J4.7; also elsewhere on the board
SDA: J1.5, J4.5; also elsewhere on the board
VCC: J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.1, J4.2, J5.1, J5.2, J6.1, J6.2; also elsewhere on the board

Parts:
C1: C_Small; C_0805_2012Metric

Connections:
GND: C1.2; also elsewhere on the board
VCC: C1.1; also elsewhere on the board

Board: 2 copper layers, 62.2 x 94.0 mm, 14 parts (0 on the bottom side), 28 nets.

## KiCad design pmod_user_peripheral/pmod_peripheral.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_3.2mm_M3_Pad_Via
J4, J5, J6: Conn_02x04_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
PMOD1, PMOD2, PMOD3: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Horizontal
PMOD4, PMOD5, PMOD6: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Horizontal

Connections:
GND: J4.9, J4.10, J5.9, J5.10, J6.9, J6.10, PMOD1.3, PMOD1.4, PMOD2.3, PMOD2.4, PMOD3.3, PMOD3.4, PMOD4.3, PMOD4.4, PMOD5.3, PMOD5.4, PMOD6.3, PMOD6.4
PMOD_I2C_GPIO1: J4.2, PMOD1.12, PMOD4.12
PMOD_I2C_GPIO2: J4.4, PMOD1.10, PMOD4.10
PMOD_I2C_GPIO3: J4.6, PMOD1.8, PMOD4.8
PMOD_I2C_GPIO4: J4.8, PMOD1.6, PMOD4.6
PMOD_I2C_INT: J4.1, PMOD1.11, PMOD4.11
PMOD_I2C_RESET: J4.3, PMOD1.9, PMOD4.9
PMOD_I2C_SCL: J4.5, PMOD1.7, PMOD4.7
PMOD_I2C_SDA: J4.7, PMOD1.5, PMOD4.5
PMOD_SPI_CS: J5.1, PMOD2.11, PMOD5.11
PMOD_SPI_GPIO1_INT: J5.2, PMOD2.12, PMOD5.12
PMOD_SPI_GPIO2_RESET: J5.4, PMOD2.10, PMOD5.10
PMOD_SPI_GPIO3_CS2: J5.6, PMOD2.8, PMOD5.8
PMOD_SPI_GPIO4_CS3: J5.8, PMOD2.6, PMOD5.6
PMOD_SPI_MISO: J5.5, PMOD2.7, PMOD5.7
PMOD_SPI_MOSI: J5.3, PMOD2.9, PMOD5.9
PMOD_SPI_SCK: J5.7, PMOD2.5, PMOD5.5
PMOD_UART_CTS: J6.1, PMOD3.11, PMOD6.11
PMOD_UART_GPIO1_INT: J6.2, PMOD3.12, PMOD6.12
PMOD_UART_GPIO2_RESET: J6.4, PMOD3.10, PMOD6.10
PMOD_UART_GPIO3: J6.6, PMOD3.8, PMOD6.8
PMOD_UART_GPIO4: J6.8, PMOD3.6, PMOD6.6
PMOD_UART_RTS: J6.7, PMOD3.5, PMOD6.5
PMOD_UART_RXD: J6.5, PMOD3.7, PMOD6.7
PMOD_UART_TXD: J6.3, PMOD3.9, PMOD6.9
VCC: J4.11, J4.12, J5.11, J5.12, J6.11, J6.12, PMOD1.1, PMOD1.2, PMOD2.1, PMOD2.2, PMOD3.1, PMOD3.2, PMOD4.1, PMOD4.2, PMOD5.1, PMOD5.2, PMOD6.1, PMOD6.2

Board: 2 copper layers, 43.2 x 88.9 mm, 13 parts (0 on the bottom side), 26 nets.

## Commit log

2021-09-18 Function Jumpers
2021-09-18 User wires pins concept
2021-09-18 Fixed COnnections wip
2021-09-19 Pinout for fixed connections
2021-09-24 Connecor
2021-09-24 gerber for fixed connections
2021-09-24 user pins with incomplkete silk
2021-12-23 Moved the debug header
2021-12-23 Moved project
2021-12-23 Moving debug connector WIP
2021-12-27 Add uart and swd headers
2021-12-27 I²C Modules Board (WIP)
2021-12-27 Updating all the pins on the modules
2021-12-30 i2c modules board
2021-12-30 fixed connections board routed
2021-12-30 Keypad + interface module on a board
2022-01-14 pmod board for rfid moduke 522,663
2022-01-14 gerber
2022-01-14 532 wip
2022-02-02 Swapped debug to board connector
2022-02-02 moved rtc battery diodes
2022-02-02 rfid straight up
2022-02-02 Moved the old to dual-down to save the design
2022-02-02 KiCAD v6
2022-02-02 Working on new design
2022-02-02 notes
2022-02-02 ELECHOUSE NFC MODULE V3 PMOD board
2022-02-02 Gerbers for PMOD RFID boards for 522 and 532
2022-02-05 thm3060 board
2022-02-05 pill fixed v1.2
2022-02-11 PN5180 PMOD board
2022-04-08 Update keypad
2022-04-08 Add reset pullup/pulldown select for 522 vs 663
2022-04-08 pmod breakout
2022-04-08 pmod breakout clean unused files
2022-04-08 pmod peripheral and master
2022-04-08 Renaming
2022-04-08 PMOD RFID Board:RobotDyn v0.2
2022-04-08 move rfid boards to their own directory
2022-04-08 rename
2022-04-10 st7920 pmod board wip
2022-07-08 Update i2c board
2022-07-08 Generate Gerbers
2022-10-03 Fix swapped SDA/SCL on OLED
2023-01-05 ESP32S3 baseboard
2023-01-05 ESP32S3 do not connect strapping pins
2023-01-05 ESP32C3 basebaord
2023-01-05 WK-W801
2023-01-05 MK-W806
2023-01-05 Replace debug connector
2023-01-05 Ignore backups
2023-01-05 HK-W806 Baseboard v0.1
2023-01-05 HK-W801 Baseboard v0.1
2023-01-05 ESP32C3 base board v0.1
2023-01-05 ESP32S3 base board v0.1
2023-01-05 HK-w80x baseboards v0.1
2023-01-05 Uncomitted ESP32 basebaord
2023-01-05 ESP32 baseboard v0.2
2023-01-05 Uncommitted BS3 baseboard
2023-01-05 Adding zipped gerbers
2023-01-05 Update silkscreen
2023-01-05 Uncomitted gerbers
2023-01-14 Update C3/S3
2023-04-21 uncommitted files
2023-04-21 move files
2023-04-27 V0.3 WIP
2023-04-28 v0.3 ANT
2023-05-21 old gerbers???
2023-05-21 pmod_e103bt53_baseboard
2023-05-26 Radio Initial v0.5 with FLASH
2023-05-26 e103bt53 baseboard
2023-06-07 m590 wip
2023-06-07 Making the hole for the antenna bigger
2023-06-09 RF4xxx v0.6
2023-06-09 Rename footprint
2023-06-09 AS4432->RF4xxx
2023-10-06 M590 PMOD v0.1
2023-10-13 m590 board
2023-10-13 display pmods
2023-10-15 add poweron connection, fix board size
2023-10-16 st7920
2023-10-20 st7920 display
2023-10-26 begin with adding the dcdc converter back
2023-10-26 power so far
2023-10-28 swpped i²c and spi
2023-10-28 m590 board v0.2 routed
2023-10-29 added a pull down resistor at the input of the fet for switching off the dcdc converter when a battery is present
2023-10-29 Didn't I make the antenna pad round already\?\!\? Again\!
2023-10-29 Re-arrange vbat selection components
2023-10-29 Align the tantalum
2023-11-07 Change holes M4->M3, rotate PCB
2023-11-09 Sim800x breakout board PMOD initial commit
2023-11-17 "6.8uH" -> "6.8 uH"
2023-11-17 added lipo charger
2023-11-17 adding an ldo
2023-11-17 the backups
2023-11-18 order v0.1
2023-11-18 clean up power section
2023-11-21 add missing capacitor to battery prot circuit
2023-12-03 v0.1 bom
2023-12-23 not committed long ago, what changed?
2023-12-23 Working on new PCB layout
2023-12-24 i2c modules board v0.4, almost done, need to add caps
2023-12-27 v0.4 ready for order; added caps and address labels
2023-12-27 Labels for address i/o
2023-12-27 I²C and SPI OLED 1.3"
2024-01-01 Another round for the modem board
2024-01-02 v0.3, driemaal is scheepsrecht
2024-01-02 v0.3 gerber and bom
2024-01-03 DSMR PMOD v0.3
2024-01-03 Gerber for DSMR v0.3
2024-01-14 smaller elco's, horizontal diodes
2024-01-14 Add jumper +3V3 -- VCC
2024-01-17 All RFM to v0.7, removed SPI Flash Enable Solderbridge
2024-01-17 CC1101 RA01 to v0.7
2024-01-17 Fix the silkscreen M1/M2/M3 placement
2024-01-17 dsmr v0.4
